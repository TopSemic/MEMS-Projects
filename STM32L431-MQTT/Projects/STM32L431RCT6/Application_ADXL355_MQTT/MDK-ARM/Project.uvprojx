# Keil uVision project Project.uvprojx, settings and files
target STM32L431RCT6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32L431RCT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L431xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../Drivers/STM32L4xx_HAL_Driver/Inc;..\Src\adxl355
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Drivers/STM32L4xx_LL_Driver
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_crc.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_usart.c stm32l4xx_ll_pwr.c stm32l4xx_ll_utils.c stm32l4xx_ll_spi.c stm32l4xx_ll_opamp.c stm32l4xx_ll_rcc.c stm32l4xx_ll_lptim.c stm32l4xx_ll_adc.c stm32l4xx_ll_dac.c stm32l4xx_ll_rng.c stm32l4xx_ll_crs.c stm32l4xx_ll_exti.c stm32l4xx_ll_rtc.c stm32l4xx_ll_tim.c stm32l4xx_ll_comp.c stm32l4xx_ll_gpio.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_i2c.c stm32l4xx_ll_dma.c
  group Example/MDK-ARM
    ./: startup_stm32l431xx.s
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l4xx_it.c mqtt_at.c angle_report.c mqtt_payload.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group bsp
    ../Src/: common.c
  group adxl355
    ../Src/adxl355/: adxl355.c
software components: CMSIS:CORE 5.6.0
